# Keil uVision project Roby-Eva.uvproj, settings and files
target Roby-Eva (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Roby-Eva +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\User;..\Lib\inc;..\BSP;..\System;..\Test;..\IRQ
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../Startup/: startup_stm32f40xx.s
  group Lib
    ../Lib/lib/: STM32F4.lib
  group System
    ../System/: system_stm32f4xx.c
  group BSP
    ../BSP/: Init.c LED.c SysTick.c USART.c NVIC.c Speaker.c LCD.c PWM.c BLD.c TIM.c IrDA.c
  group IRQ
    ../IRQ/: stm32f4xx_it.c
  group User
    ../User/: main.c common.c Filtering_Algorithm.c Sensor_Acquisition.c MagneticNavigation.c PID_Calculation.c PWM_Output.c Station_Handler.c RFID.c Remote_Control.c VoiceHandler.c FoodMenue.c Dance.c UART_Protocol.c MiscIO.c ResetMode.c
  group Test
    ../Test/: test.c Reserved.c
  group Readme
    ../Readme/: Readme.txt
